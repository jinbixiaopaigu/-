# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BUZZER;..\SYSTEM\TIMER;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\NET\device;..\NET\MQTT;..\NET\onenet;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\GY906;..\HARDWARE\DYSV17F;..\HARDWARE\LSENS;..\HARDWARE\ATGM336H;..\HARDWARE\Menu;..\HARDWARE\OLED1;..\HARDWARE\ADC;..\HARDWARE\max30102iic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BUZZER/: beep.c
    ../HARDWARE/GY906/: MLX90614.c
    ../HARDWARE/DYSV17F/: sv17f.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ATGM336H/: ATGM336H.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Menu/: menu.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/OLED1/: oled.c
    ../HARDWARE/MPU6050/: mpu6050.c myiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/max30102iic/: algorithm.c max30102.c maxiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIMER/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_flash.c
  group README
    ../: README.TXT
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
